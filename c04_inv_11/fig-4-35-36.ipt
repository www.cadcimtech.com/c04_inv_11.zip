# Autodesk Inventor part: fig-4-35-36
## iProperties
Created: 2005-12
Part Number: fig-4-35-36
Document SubType Name: Modeling
Designer: CADCIM
Author: CADCIM
## Feature names
1. Extrusion1
