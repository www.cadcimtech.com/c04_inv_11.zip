# Autodesk Inventor part: fig-4-37
## iProperties
Created: 2005-12
Part Number: fig-4-37
Document SubType Name: Modeling
Designer: CADCIM
Author: CADCIM
## Feature names
1. Extrusion1
